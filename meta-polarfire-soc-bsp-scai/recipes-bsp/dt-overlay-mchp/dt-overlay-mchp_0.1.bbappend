
COMPATIBLE_MACHINE = "(icicle-kit|mpfs-video-kit|scai-navc|scai-dpu)"

