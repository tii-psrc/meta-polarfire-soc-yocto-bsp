IMAGE_INSTALL:append:scai-navc = " \
    "

IMAGE_INSTALL:append:scai-dpu = " \
    "

