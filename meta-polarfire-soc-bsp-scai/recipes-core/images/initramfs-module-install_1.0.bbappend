IMAGE_NAME_SUFFIX:scai-navc = ""
IMAGE_NAME_SUFFIX:scai-dpu = ""

COMPATIBLE_HOST:append = "|riscv.*-(linux.*|freebsd.*)"
